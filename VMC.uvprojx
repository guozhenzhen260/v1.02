# Keil uVision project VMC.uvprojx, settings and files
target VMC_Release_In_Flash (5060020::V5.06 (build 20)::ARMCC)
  device: LPC1768 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LF_VMC_V102 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group APP
    ./APP/: main.c Android.c vendservice.c maintenance.c Log.c ParamDefine.c MdbBillDeviceOperation.c MdbCashlessDeviceOperation.c MdbCoinDeviceOperation.c Menu.c
  group API
    ./API/: System.C CoinAcceptorChanger.C BillValidatorRecycler.C COM.C Display.C Keyboard.C FRAM.C RealTimeClock.C Vending.C
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/: port.c heap.c FreeRTOSHooks.c
  group DRIVERS
    ./DRIVERS/: UART0.C UART3.C PINSELECT.C RTC.C LCM.C KEY.C TIMER.C BUZZER.C I2C.C MDB.C MOTOR.C
  group LIB
    ./DRIVERS/: LIB.C
  group CMISI
    ./CMISI/: system_LPC17xx.c
    ./CMISI/STARTUP/: startup_LPC17xx.s
